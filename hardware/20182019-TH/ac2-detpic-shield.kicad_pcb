# Repository dvcorreia/ac2-detpic-pcb-shield

File README.md:

<p align="center">This repository contains hardware designs for a PCB shield that extends the detpic32 development board created at DETI UA

</p>

## Description

This project provides a solution to the transportation and handle of the circuitry needed to extend the detpic development board functionalities for the subject of Computer Arquitectures II at Deti UA.

The most frequent situation that the students enrolled in the subject experience is the circuitry assembly in low quality bread boards, usually poorly mounted and disorganized. The transportation inside the backpacks usually causes faulty connections, sometimes hard to debug.

The shield provides a robust solution, easy to transport, user friendly and fault proof.

There are also cases for some of the PCBs that you can 3D print and use! Check inside the PCB folder for the `./cases` directory.

> __The existence of this pcb doesn't imply that the students shouldn't prototype the circuitry in the bread board at least once. It is important that the student understands the schematic and be able to assembly the circuit autonomously.__

## Customize

Most likely you will have to change the PCB, since you might not have some of the components or you have to add a few more. We can't (shouldn't) do it for you, so you have to learn how to work with [Kicad](http://kicad-pcb.org/). Kicad is an open-source PCB designer with builds for every platform. You can read the documentation and there are plenty of tutorials on Youtube.

This is an open source project, so feel free to change the board to your preferences, e.g. add more LEDs, put your name in the PCB, change the components to your needs, etc.

Every PCB in this repo has a README that can be found in the root directory of the respective project folder. This document has useful information that should be read if you plan to modify it.

## Order

Before you order, print the gerber in a sheet of paper and test fit with your components. Boards might have errors or incompatibilities.

The suggested PCB prototype manufacturer is [JLCPCB](https://jlcpcb.com/). It is cheap, less that 10€ for 5 PCBs (< 100x100mm), and you can order it with other students. We have used it before and the quality is ok. Feel free to DIY.

To order you just need to upload the gerber files and follow the instructions in the respective manufacturer website. The gerber files can be found in the gerber folder inside the board project directory.

## Boards

| Name                                                                                                    | Descripion                                   | Tested       |
|---------------------------------------------------------------------------------------------------------|----------------------------------------------|--------------|
| [__20182019-TH-V1.1__](https://github.com/dvcorreia/ac2-detpic-shield/tree/master/hardware/20182019-TH) | 1st version of the through hole 2019's board | :red_circle: |

## Issues

Any issue or question can be reported here on Github on the [issues](https://github.com/dvcorreia/ac2-detpic-shield/issues) tab. Remember to describe the problem clearly, write the process so we can emulate the problem. Print-screens might be useful to.
We will try to answer you as fast as possible.

## Contributing

Feel free to contribute your version of the PCB! Others might enjoy it and would like to use it.

To do so, open a [pull request](https://help.github.com/en/articles/about-pull-requests). Make sure to follow the organization structure
already implemented. Don't forget to add a README with useful information. Check the one in _20182019-TH_ project directory has an example.

## License & Copyright

This program is free software: you can redistribute it and/or modify
it under the terms of the GNU General Public License as published by
the Free Software Foundation, either version 3 of the License, or
(at your option) any later version.

This program is distributed in the hope that it will be useful,
but WITHOUT ANY WARRANTY; without even the implied warranty of
MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
GNU General Public License for more details.

You should have received a copy of the GNU General Public License
along with this program.  If not, see <https://www.gnu.org/licenses/>.

_Copyright 2019 Diogo Correia_

## KiCad design hardware/20182019-TH/ac2-detpic-shield.kicad_pcb

File hardware/20182019-TH/README.md:

# 20182019-TH-V1.0

    Name: 20182019-TH-V1.1
    Year: 2018/2019
    Size: 99.06mm x 69.6mm
    Author: Diogo Correia (@dvcorreia)

## Render

Make sure that your components footprints are the ones been used in this PCB. If not be sure to change them.
There is a __test-fit.pdf__ inside the /docs folder that you can print to check if your components fit.

## Description

- This board implements the default circuitry of the 2018/2019 subject guide
- All of its components are throught hole
- The routes were computed using [Freerouting](https://freerouting.org/freerouting/using-with-kicad)

## Sugestions

- Replace some throught hole components with SMD
- Use resistor arrays

## Pins

| N  | CN1  | Description          | CN2  | Description   |
|----|------|----------------------|------|---------------|
| 1  | RE7  | -                    | RB6  | -             |
| 2  | RE6  | -                    | RB5  | -             |
| 3  | RE5  | -                    | RB4  | Potentiometer |
| 4  | RE4  | -                    | RB3  | DIP Switch x4 |
| 5  | RE3  | LEDS                 | RB2  | DIP Switch x4 |
| 6  | RE2  | LEDS                 | RB1  | DIP Switch x4 |
| 7  | RE1  | LEDS                 | RB0  | DIP Switch x4 |
| 8  | RE0  | LEDS                 | RB7  | -             |
| 9  | RG7  | EEPROM 1             | RB8  | 7 SEG Display |
| 10 | RG8  | EEPROM 1             | RB9  | 7 SEG Display |
| 11 | RG9  | EEPROM 1             | RB10 | 7 SEG Display |
| 12 | RD7  | -                    | RB11 | 7 SEG Display |
| 13 | RD6  | 7 SEG Display Switch | RB12 | 7 SEG Display |
| 14 | RD5  | 7 SEG Display Switch | RB13 | 7 SEG Display |
| 15 | RD4  | -                    | RB14 | 7 SEG Display |
| 16 | RD3  | -                    | RB15 | 7 SEG Display |
| 17 | RD2  | -                    | RF0  | -             |
| 18 | RD1  | -                    | RF1  | -             |
| 19 | RD0  | -                    | RF3  | -             |
| 20 | RD11 | -                    | RF4  | -             |
| 21 | RD10 | Temperature Sensor   | RF5  | -             |
| 22 | RD9  | Temperature Sensor   | VBUS | -             |
| 23 | RD8  | -                    | VUSB | -             |
| 24 | RG3  | -                    | RG2  | -             |
| 25 | RG6  | EEPROM 1             | RC13 | -             |

Parts:
C1: 100nF; C_Disc_D6.0mm_W2.5mm_P5.00mm
C2, C4, C5, C7, C8, C12: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3, C6: 4.7uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C9: 10uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C10, C11: 20pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2, D3, D4: LED; LED_D3.0mm
D5: D_Small; D_A-405_P7.62mm_Horizontal
D6, D7: LED; LED_0603_1608Metric
J1: HEADER; PinHeader_1x04_P2.54mm_Vertical
J2, J6: HEADER; PinHeader_1x01_P2.54mm_Vertical
J3: HEADER; PinHeader_1x06_P2.54mm_Vertical
J4, J5: HEADER; PinHeader_1x02_P2.54mm_Vertical
J7: HEADER; PinHeader_1x09_P2.54mm_Vertical
J8: MPLAB ICD3; PinHeader_1x06_P2.54mm_Horizontal
MCU1: CN1(DETPIC32); PinSocket_1x28_P2.54mm_Vertical
MCU2: CN2(DETPIC32); PinSocket_1x28_P2.54mm_Vertical
Q1, Q2: VN2222; TO-92
R1, R4, R5, R6, R13, R24: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2, R3, R7, R8: 270; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R9, R10, R11, R12: 470; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R14, R15, R16, R17, R18, R19, R20, R21, R26, R27: 330; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R22, R23: 2k7; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R25: 4k7; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RV1: 10k; Potentiometer_ACP_CA9-V10_Vertical
RV2: 10k; Potentiometer_Alps_RK163_Single_Horizontal
SW1: SW_DIP_x04; SW_DIP_SPSTx04_Slide_9.78x12.34mm_W7.62mm_P2.54mm
SW2: SW_Push; SW_PUSH_6mm
TP1: Test Point GND; TestPoint_Pad_2.5x2.5mm
U1: 25LC040A; DIP-8_W7.62mm_Socket_LongPads
U2: LTD-4708JR
U3: TC74; TO-220-5_Horizontal_TabDown
U4, U5: KCSA02-107; 7SegmentLED_LTS6760_LTS6780
U6: PIC32MX795F512H-80V_PT; TQFP64_10X10MC
U7: TC1262-33; SOT-223
U8: MM232R; FTDI_MM232R
Y1: 8MHz; Crystal_HC49-4H_Vertical

Connections:
/7A: R14.1, U2.10 (A), U4.7 (A), U5.7 (A)
/7B: R15.1, U2.8 (B), U4.6 (B), U5.6 (B)
/7C: R16.1, U2.1 (C), U4.4 (C), U5.4 (C)
/7C1: Q1.1 (D), U2.9 (C1), U4.3 (CA), U4.8 (CA)
/7C2: Q2.1 (D), U2.4 (C2), U5.3 (CA), U5.8 (CA)
/7D: R17.1, U2.5 (D), U4.2 (D), U5.2 (D)
/7DP: R21.1, U2.2 (DP), U4.5 (DP), U5.5 (DP)
/7E: R18.1, U2.3 (E), U4.1 (E), U5.1 (E)
/7F: R19.1, U2.6 (F), U4.9 (F), U5.9 (F)
/7G: R20.1, U2.7 (G), U4.10 (G), U5.10 (G)
/+3.3V: C2.1, C4.1, C5.1, C6.1, C7.1, C8.1, J8.5, MCU1.26 (+3.3V), MCU2.26 (+3.3V), R9.1, R10.1, R11.1, R12.1, R22.1, R23.1, R25.2, R26.2, RV1.1, RV2.1, U1.7 (~HOLD), U1.8 (VCC), U3.5 (VCC), U6.10 (VDD_2), U6.19 (AVDD), U6.26 (VDD_3), U6.38 (VDD_4), U6.57 (VDD), U7.3 (VO)
/+5V_EXT: C3.1, D5.1 (K), MCU1.27 (+5V_EXT), MCU2.27 (+5V_EXT), U7.1 (VI)
/+5V_USB: D5.2 (A), U8.2 (VCC)
/MCLR: J8.6
/PGC: J5.2, J8.2, MCU2.1 (RB6), U6.17 (PGEC2/AN6/OCFA/RB6)
/PGD: J6.1, J8.3, MCU2.8 (RB7), U6.18 (PGED2/AN7/RB7)
/RB0: MCU2.7 (RB0), R6.1, SW1.1, U6.16 (PGED1/AN0/VREF+/CVREF+/PMA6/CN2/RB0)
/RB1: MCU2.6 (RB1), R5.1, SW1.2, U6.15 (PGEC1/AN1/VREF-/CVREF-/CN3/RB1)
/RB2: MCU2.5 (RB2), R4.1, SW1.3, U6.14 (AN2/C2IN-/CN4/RB2)
/RB3: MCU2.4 (RB3), R1.1, SW1.4, U6.13 (AN3/C2IN+/CN5/RB3)
/RB4: MCU2.3 (RB4), RV1.2, RV2.2, U6.12 (AN4/C1IN-/CN6/RB4)
/RB5: J5.1, MCU2.2 (RB5), U6.11 (AN5/C1IN+/VBUSON/CN7/RB5)
/RB8: MCU2.9 (RB8), R14.2, U6.21 (AN8/C2TX/*SS3A/U3BRX/*U3ACTS/C1OUT/RB8)
/RB9: MCU2.10 (RB9), R15.2, U6.22 (AN9/C2OUT/PMA7/RB9)
/RB10: MCU2.11 (RB10), R16.2, U6.23 (TMS/AN10/CVREFOUT/PMA13/RB10)
/RB11: MCU2.12 (RB11), R17.2, U6.24 (TDO/AN11/PMA12/RB11)
/RB12: MCU2.13 (RB12), R18.2, U6.27 (TCK/AN12/PMA11/RB12)
/RB13: MCU2.14 (RB13), R19.2, U6.28 (TDI/AN13/PMA10/RB13)
/RB14: MCU2.15 (RB14), R20.2, U6.29 (AN14/C2RX/SCK3A/U3BTX/*U3ARTS/PMALH/PMA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)
/RB15: MCU2.16 (RB15), R21.2, U6.30 (AN15/EMDC/OCFB/PMALL/PMA0/CN12/RB15)
/RC12: C11.1, U6.39 (OSC1/CLKI/RC12), Y1.2
/RC13: J7.1, MCU2.25 (RC13), U6.47 (SOSCI/CN1/RC13)
/RC15: C10.1, U6.40 (OSC2/CLKO/RC15), Y1.1
/RD0: J3.2, MCU1.19 (RD0), R27.1, U6.46 (OC1/INT0/RD0)
/RD1: J3.3, MCU1.18 (RD1), U6.49 (EMDIO/SCK1A/U1BTX/*U1ARTS/OC2/RD1)
/RD2: J3.4, MCU1.17 (RD2), U6.50 (SDA1A/SDI1A/U1ARX/OC3/RD2), U8.7 (RXD)
/RD3: J3.5, MCU1.16 (RD3), U6.51 (SCL1A/SDO1A/U1ATX/OC4/RD3), U8.5 (TXD)
/RD4: J3.6, MCU1.15 (RD4), U6.52 (OC5/IC5/PMWR/CN13/RD4)
/RD5: MCU1.14 (RD5), Q2.2 (G), R24.2, U6.53 (PMRD/CN14/RD5)
/RD6: MCU1.13 (RD6), Q1.2 (G), R13.2, U6.54 (AETXEN/ETXERR/CN15/RD6)
/RD7: J2.1, MCU1.12 (RD7), U6.55 (ETXCLK/AERXERR/CN16/RD7)
/RD8: J4.2, MCU1.23 (RD8), U6.42 (RTCC/AERXD1/ETXD3/IC1/INT1/RD8)
/RD9: MCU1.22 (RD9), R23.2, U3.2 (SDA), U6.43 (AERXD0/ETXD2/*SS1A/U1BRX/*U1ACTS/SDA1/I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)
/RD10: MCU1.21 (RD10), R22.2, U3.4 (SCL), U6.44 (ECOL/AERXDV/SCL1/IC3/PMCS2/PMA15/INT3/R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)
/RD11: J3.1, MCU1.20 (RD11), U6.45 (ECRS/AERXCLK/IC4/PMCS1/PMA14/INT4/RD11)
/RE0: MCU1.8 (RE0), R8.1, U6.60 (ERXD1/PMD0/RE0)
/RE1: MCU1.7 (RE1), R7.1, U6.61 (ERXD0/PMD1/RE1)
/RE2: MCU1.6 (RE2), R2.2, U6.62 (ERXDV/PMD2/RE2)
/RE3: MCU1.5 (RE3), R3.2, U6.63 (ERXCLK/PMD3/RE3)
/RE4: J1.1, MCU1.4 (RE4), U6.64 (ERXERR/PMD4/RE4)
/RE5: J1.2, MCU1.3 (RE5), U6.1 (ETXEN/PMD5/RE5)
/RE6: J1.3, MCU1.2 (RE6), U6.2 (ETXD0/PMD6/RE6)
/RE7: J1.4, MCU1.1 (RE7), U6.3 (ETXD1/PMD7/RE7)
/RF0: J7.9, MCU2.17 (RF0), U6.58 (C1RX/AETXD1/ERXD3/RF0)
/RF1: J7.8, MCU2.18 (RF1), U6.59 (C1TX/AETXD0/ERXD2/RF1)
/RF3: J7.7, MCU2.19 (RF3), U6.33 (USBID/RF3)
/RF4: J7.6, MCU2.20 (RF4), U6.31 (AC1TX/SDA3A/SDI3A/U3ARX/PMA9/CN17/RF4)
/RF5: J7.5, MCU2.21 (RF5), U6.32 (AC1RX/SCL3A/SDO3A/U3ATX/PMA8/CN18/RF5)
/RG2: J7.2, MCU2.24 (RG2), U6.37 (D+/RG2)
/RG3: J4.1, MCU1.24 (RG3), U6.36 (D-/RG3)
/RG6: MCU1.25 (RG6), U1.6 (SCK), U6.4 (SCK2A/U2BTX/*U2ARTS/PMA5/CN8/RG6)
/RG7: MCU1.9 (RG7), U1.2 (MISO), U6.5 (SDA2A/SDI2A/U2ARX/PMA4/CN9/RG7)
/RG8: MCU1.10 (RG8), U1.5 (MOSI), U6.6 (SCL2A/SDO2A/U2ATX/PMA3/CN10/RG8)
/RG9: MCU1.11 (RG9), U1.1 (~CS), U6.8 (*SS2A/U2BRX/*U2ACTS/PMA2/CN11/RG9)
/VBUS: J7.4, MCU2.22 (VBUS), U6.34 (VBUS)
/VCAP: C9.1, C12.1, U6.56 (VCAP/VCORE)
/VUSB: J7.3, MCU2.23 (VUSB), U6.35 (VUSB)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D6.1 (K), D7.1 (K), J8.4, MCU1.28 (GND), MCU2.28 (GND), R1.2, R4.2, R5.2, R6.2, RV1.3, RV2.3, SW2.2, TP1.1, U1.4 (GND), U3.3 (GND), U6.9 (VSS_2), U6.20 (AVSS), U6.25 (VSS_3), U6.41 (VSS), U7.2 (GND), U8.13 (GND)
unnamed: C1.1, U1.3 (~WP)
unnamed: D1.2 (A), R3.1
unnamed: D2.2 (A), R2.1
unnamed: D3.2 (A), R7.2
unnamed: D4.2 (A), R8.2
unnamed: D6.2 (A), R26.1
unnamed: D7.2 (A), R27.2
unnamed: Q1.3 (S), Q2.3 (S), R13.1, R24.1
unnamed: R9.2, SW1.8
unnamed: R10.2, SW1.7
unnamed: R11.2, SW1.6
unnamed: R12.2, SW1.5
unnamed: R25.1, SW2.1, U6.7 (*MCLR)
unnamed: U8.1 (SHIELD), U8.16 (SHIELD)
unnamed: U8.3 (VCCIO), U8.4 (VCC3O)
unnamed: U8.14 (VCC5O), U8.15 (USBPWR)

Notes on the sheet:
ac2-detpic-pcb.sch
PCB Shield that extends the detpic32 development board
March 2019
DETPIC32
BASIC I/O
DISPLAY SYSTEM
EEPROM MEMORY
TEMPERATURE SENSOR
GND TP
v1.1 May 2019
Support for dual single 7seg displays
Extra potentiometer for rotary option
FTID
An expensive one
POWER DELIVERY
PROGRAMMING INTERFACES

Board: 2 copper layers, 79 parts (24 on the bottom side), 83 nets, no tracks yet.

Other parts of the board:
M1: M1; MountingHole_2.2mm_M2
M2: M2; MountingHole_2.2mm_M2
M3, M4: MountingHole_2.2mm_M2
REF1: WEEE-Logo_4.2x6mm_SilkScreen
REF2: OSHW-Logo2_14.6x12mm_SilkScreen
REF3: KiCad-Logo2_5mm_SilkScreen

## KiCad design hardware/20182019-TH-V1.0/ac2-detpic-shield.kicad_pcb

File hardware/20182019-TH-V1.0/README.md:

# 20182019-TH-V1.0

    Name: 20182019-TH-V1.0
    Year: 2018/2019
    Size: 99.06mm x 69.6mm
    Author: Diogo Correia (@dvcorreia)

## Render

Make sure that your components footprints are the ones been used in this PCB. If not be sure to change them.

## Description

- This board implements the default circuitry of the 2018/2019 subject guide
- All of its components are throught hole
- The routes were computed using [Freerouting](https://freerouting.org/freerouting/using-with-kicad)

## Sugestions

- Replace some throught hole components with SMD
- Use resistor arrays

## Pins

- :white_check_mark:: not being used 

- :red_circle:: being used

| N  | CN1  | DESCRIPTION          | STATE              | CN2  | DESCRIPTION   | STATE              |
|----|------|----------------------|--------------------|------|---------------|--------------------|
| 1  | RE7  | -                    | :white_check_mark: | RB6  | -             | :white_check_mark: |
| 2  | RE6  | -                    | :white_check_mark: | RB5  | -             | :white_check_mark: |
| 3  | RE5  | -                    | :white_check_mark: | RB4  | POTENTIOMETER | :red_circle:       |
| 4  | RE4  | -                    | :white_check_mark: | RB3  | DIP SWITCH x4 | :red_circle:       |
| 5  | RE3  | LEDS                 | :red_circle:       | RB2  | DIP SWITCH x4 | :red_circle:       |
| 6  | RE2  | LEDS                 | :red_circle:       | RB1  | DIP SWITCH x4 | :red_circle:       |
| 7  | RE1  | LEDS                 | :red_circle:       | RB0  | DIP SWITCH x4 | :red_circle:       |
| 8  | RE0  | LEDS                 | :red_circle:       | RB7  | -             | :white_check_mark: |
| 9  | RG7  | EEPROM 1             | :red_circle:       | RB8  | 7 SEG DISPLAY | :red_circle:       |
| 10 | RG8  | EEPROM 1             | :red_circle:       | RB9  | 7 SEG DISPLAY | :red_circle:       |
| 11 | RG9  | EEPROM 1             | :red_circle:       | RB10 | 7 SEG DISPLAY | :red_circle:       |
| 12 | RD7  | -                    | :white_check_mark: | RB11 | 7 SEG DISPLAY | :red_circle:       |
| 13 | RD6  | 7 SEG DISPLAY SWITCH | :red_circle:       | RB12 | 7 SEG DISPLAY | :red_circle:       |
| 14 | RD5  | 7 SEG DISPLAY SWITCH | :red_circle:       | RB13 | 7 SEG DISPLAY | :red_circle:       |
| 15 | RD4  | -                    | :white_check_mark: | RB14 | 7 SEG DISPLAY | :red_circle:       |
| 16 | RD3  | -                    | :white_check_mark: | RB15 | 7 SEG DISPLAY | :red_circle:       |
| 17 | RD2  | -                    | :white_check_mark: | RF0  | -             | :white_check_mark: |
| 18 | RD1  | -                    | :white_check_mark: | RF1  | -             | :white_check_mark: |
| 19 | RD0  | -                    | :white_check_mark: | RF3  | -             | :white_check_mark: |
| 20 | RD11 | -                    | :white_check_mark: | RF4  | -             | :white_check_mark: |
| 21 | RD10 | TEMPERATURE SENSOR   | :red_circle:       | RF5  | -             | :white_check_mark: |
| 22 | RD9  | TEMPERATURE SENSOR   | :red_circle:       | VBUS | -             | :white_check_mark: |
| 23 | RD8  | -                    | :white_check_mark: | VUSB | -             | :white_check_mark: |
| 24 | RG3  | -                    | :white_check_mark: | RG2  | -             | :white_check_mark: |
| 25 | RG6  | EEPROM 1             | :red_circle:       | RC13 | -             | :white_check_mark: |

Parts:
C1: 100nF; CP_Radial_D7.5mm_P2.50mm
D1, D2, D3, D4: LED; LED_D3.0mm
J1: HEADER; PinHeader_1x04_P2.54mm_Vertical
J2, J6: HEADER; PinHeader_1x01_P2.54mm_Vertical
J3: HEADER; PinHeader_1x07_P2.54mm_Vertical
J4, J5: HEADER; PinHeader_1x02_P2.54mm_Vertical
J7: HEADER; PinHeader_1x09_P2.54mm_Vertical
MCU1: CN1(DETPIC32); PinSocket_1x28_P2.54mm_Vertical
MCU2: CN2(DETPIC32); PinSocket_1x28_P2.54mm_Vertical
Q1, Q2: VN2222; TO-92
R1, R4, R5, R6, R13, R24: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2, R3, R7, R8: 270; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9, R10, R11, R12: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R14, R15, R16, R17, R18, R19, R20, R21: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R22, R23: 2k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: 10k; Potentiometer_ACP_CA14V-15_Vertical
SW1: SW_DIP_x04; SW_DIP_SPSTx04_Slide_9.78x12.34mm_W7.62mm_P2.54mm
U1: 25LC040A; DIP-8_W7.62mm_Socket_LongPads
U2: LTD-4708JR
U3: TC74; TO-220-5_Horizontal_TabDown

Connections:
/+3.3V: MCU1.26 (+3.3V), MCU2.26 (+3.3V), R9.1, R10.1, R11.1, R12.1, R22.1, R23.1, RV1.1, U1.7 (~HOLD), U1.8 (VCC), U3.5 (VCC)
/+5V_EXT1: MCU1.27 (+5V_EXT)
/+5V_EXT2: MCU2.27 (+5V_EXT)
/RB0: MCU2.7 (RB0), R6.1, SW1.1
/RB1: MCU2.6 (RB1), R5.1, SW1.2
/RB2: MCU2.5 (RB2), R4.1, SW1.3
/RB3: MCU2.4 (RB3), R1.1, SW1.4
/RB4: MCU2.3 (RB4), RV1.2
/RB5: J5.1, MCU2.2 (RB5)
/RB6: J5.2, MCU2.1 (RB6)
/RB7: J6.1, MCU2.8 (RB7)
/RB8: MCU2.9 (RB8), R14.2
/RB9: MCU2.10 (RB9), R15.2
/RB10: MCU2.11 (RB10), R16.2
/RB11: MCU2.12 (RB11), R17.2
/RB12: MCU2.13 (RB12), R18.2
/RB13: MCU2.14 (RB13), R19.2
/RB14: MCU2.15 (RB14), R20.2
/RB15: MCU2.16 (RB15), R21.2
/RC13: J7.1, MCU2.25 (RC13)
/RD0: J3.3, MCU1.19 (RD0)
/RD1: J3.4, MCU1.18 (RD1)
/RD2: J3.5, MCU1.17 (RD2)
/RD3: J3.6, MCU1.16 (RD3)
/RD4: J3.7, MCU1.15 (RD4)
/RD5: MCU1.14 (RD5), Q2.2 (G), R24.2
/RD6: MCU1.13 (RD6), Q1.2 (G), R13.2
/RD7: J2.1, MCU1.12 (RD7)
/RD8: J4.2, MCU1.23 (RD8)
/RD9: MCU1.22 (RD9), R23.2, U3.2 (SDA)
/RD10: J3.1, MCU1.21 (RD10), R22.2, U3.4 (SCL)
/RD11: J3.2, MCU1.20 (RD11)
/RE0: MCU1.8 (RE0), R8.1
/RE1: MCU1.7 (RE1), R7.1
/RE2: MCU1.6 (RE2), R2.2
/RE3: MCU1.5 (RE3), R3.2
/RE4: J1.1, MCU1.4 (RE4)
/RE5: J1.2, MCU1.3 (RE5)
/RE6: J1.3, MCU1.2 (RE6)
/RE7: J1.4, MCU1.1 (RE7)
/RF0: J7.9, MCU2.17 (RF0)
/RF1: J7.8, MCU2.18 (RF1)
/RF3: J7.7, MCU2.19 (RF3)
/RF4: J7.6, MCU2.20 (RF4)
/RF5: J7.5, MCU2.21 (RF5)
/RG2: J7.2, MCU2.24 (RG2)
/RG3: J4.1, MCU1.24 (RG3)
/RG6: MCU1.25 (RG6), U1.6 (SCK)
/RG7: MCU1.9 (RG7), U1.2 (MISO)
/RG8: MCU1.10 (RG8), U1.5 (MOSI)
/RG9: MCU1.11 (RG9), U1.1 (~CS)
/VBUS: J7.4, MCU2.22 (VBUS)
/VUSB: J7.3, MCU2.23 (VUSB)
GND: C1.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), MCU1.28 (GND), MCU2.28 (GND), R1.2, R4.2, R5.2, R6.2, RV1.3, U1.4 (GND), U3.3 (GND); also elsewhere on the board
unnamed: C1.1, U1.3 (~WP)
unnamed: D1.2 (A), R3.1
unnamed: D2.2 (A), R2.1
unnamed: D3.2 (A), R7.2
unnamed: D4.2 (A), R8.2
unnamed: Q1.1 (D), U2.9 (C1)
unnamed: Q1.3 (S), Q2.3 (S), R13.1, R24.1
unnamed: Q2.1 (D), U2.4 (C2)
unnamed: R9.2, SW1.8
unnamed: R10.2, SW1.7
unnamed: R11.2, SW1.6
unnamed: R12.2, SW1.5
unnamed: R14.1, U2.10 (A)
unnamed: R15.1, U2.8 (B)
unnamed: R16.1, U2.1 (C)
unnamed: R17.1, U2.5 (D)
unnamed: R18.1, U2.3 (E)
unnamed: R19.1, U2.6 (F)
unnamed: R20.1, U2.7 (G)
unnamed: R21.1, U2.2 (DP)

Notes on the sheet:
Licence: MIT Copyright 2019 Diogo Correia PCB Shield that extends the detpic32 development board created at DETI UA This schematic is intended to be updated has the subject evolves Feel free to request changes or make them yourself Consider contributing your changes to the repo
ac2-detpic-pcb.sch
PCB Shield that extends the detpic32 development board
March 2019
DETPIC32
BASIC I/O
DISPLAY SYSTEM
EEPROM MEMORY
TEMPERATURE SENSOR

Board: 2 copper layers, 99.1 x 69.6 mm, 54 parts (8 on the bottom side), 72 nets.

Other parts of the board:
M1: M1; MountingHole_2.2mm_M2
M2: M2; MountingHole_2.2mm_M2
M3, M4: MountingHole_2.2mm_M2
REF1: WEEE-Logo_4.2x6mm_SilkScreen
REF2: OSHW-Logo2_14.6x12mm_SilkScreen
REF3, REF4: KiCad-Logo2_5mm_SilkScreen
grab your GND here: Test Point GND; TestPoint_Pad_2.5x2.5mm

Their connections:
GND: grab your GND here.1; also elsewhere on the board

## Commit log

2019-03-17 project started!
2019-03-24 reformulation of library handle
2019-03-24 added eeprom module
2019-03-24 added temperature sensor module
2019-03-25 LTD-4708JR footprint created and footprints assigment completed
2019-03-25 file structure in docs changed + pcb layout and detpic aux info done
2019-03-26 pcb completed + gerbers exported
2019-03-26 folder structure changed to handle more pcbs version + main README done
2019-03-28 detpic32 size fixed, freeroute files and organization file directory changes
2019-03-29 added basic documentation to 20182019-TH-V1.0 board
2019-03-29 added docs of 20182019-TH-V.1
2019-03-29 added test fit pdf to 20182019-TH-V1.0
2019-03-29 test fit of 20182019-TH-V1.0 replaced
2019-04-15 added license 📄
2019-05-18 added gnd test point to 20182019-TH v1.1
2019-05-18 changed folder structure
2019-05-18 arrangement in the M4 label in 20182019-TH board
2019-05-18 added tested column to boards description
2019-05-18 small fix in README.md
2019-05-27 updated readme.md with license and copyright
2019-05-29 changed stuff in the back silk
2019-05-29 fixed bug in J3 header in 20182019-TH pcb
2019-05-29 changed README.md to clean information in 20182019-TH board
2019-05-29 new gerbers and fix in README.md of the 20192018-TH board
2019-07-07 added photo of 20182019-TH version 1.1 pcb
2019-07-18 Added Box and Stand
    Added Box (Box.stl) and Box Cover (BoxCover.stl).
    Added simple Stand with 20º inclination (Stand.stl)
2019-07-18 Details
2019-07-18 corrected spelling errors + changed cases organization + added cases docs
2019-07-19 Rename Readme to README.md
2019-07-19 Organization in folders; update on objects and creation of slim versions
2019-07-19 Removal of old versions
2019-07-19 Update objects, added slim version
2019-07-19 remove old version
2020-03-04 rotary pot, option on dual single 7seg displays and fix in trim pot
2020-03-04 changes docs of detpic to common directory + changes in the pcb and footprint (rotary pot)
2020-03-14 added detpic32 circuitry to schematic
2020-03-14 added footprints, changes footprints and generated new net file
2020-03-14 small pcb organization of components
2020-03-15 some changes to pcb and footprints on pF caps to 0805
2020-03-15 changed smd development folder name
2020-03-17 added some routing
2020-03-20 pcb work
